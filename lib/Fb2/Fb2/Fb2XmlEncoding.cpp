#include "Fb2XmlEncoding.h"

#include <cstdint>

namespace {
// Sentinel for byte values the codepage leaves unassigned (expat wants -1).
constexpr uint16_t UNASSIGNED = 0xFFFF;

// windows-1251 high half (0x80-0xFF) -> Unicode code points.
// constexpr keeps the table in flash (instruction bus), not DRAM.
constexpr uint16_t CP1251_HIGH[128] = {
    0x0402, 0x0403, 0x201A, 0x0453, 0x201E, 0x2026, 0x2020, 0x2021,  // 0x80-0x87
    0x20AC, 0x2030, 0x0409, 0x2039, 0x040A, 0x040C, 0x040B, 0x040F,  // 0x88-0x8F
    0x0452, 0x2018, 0x2019, 0x201C, 0x201D, 0x2022, 0x2013, 0x2014,  // 0x90-0x97
    UNASSIGNED, 0x2122, 0x0459, 0x203A, 0x045A, 0x045C, 0x045B, 0x045F,  // 0x98-0x9F
    0x00A0, 0x040E, 0x045E, 0x0408, 0x00A4, 0x0490, 0x00A6, 0x00A7,  // 0xA0-0xA7
    0x0401, 0x00A9, 0x0404, 0x00AB, 0x00AC, 0x00AD, 0x00AE, 0x0407,  // 0xA8-0xAF
    0x00B0, 0x00B1, 0x0406, 0x0456, 0x0491, 0x00B5, 0x00B6, 0x00B7,  // 0xB0-0xB7
    0x0451, 0x2116, 0x0454, 0x00BB, 0x0458, 0x0405, 0x0455, 0x0457,  // 0xB8-0xBF
    0x0410, 0x0411, 0x0412, 0x0413, 0x0414, 0x0415, 0x0416, 0x0417,  // А-З
    0x0418, 0x0419, 0x041A, 0x041B, 0x041C, 0x041D, 0x041E, 0x041F,  // И-П
    0x0420, 0x0421, 0x0422, 0x0423, 0x0424, 0x0425, 0x0426, 0x0427,  // Р-Ч
    0x0428, 0x0429, 0x042A, 0x042B, 0x042C, 0x042D, 0x042E, 0x042F,  // Ш-Я
    0x0430, 0x0431, 0x0432, 0x0433, 0x0434, 0x0435, 0x0436, 0x0437,  // а-з
    0x0438, 0x0439, 0x043A, 0x043B, 0x043C, 0x043D, 0x043E, 0x043F,  // и-п
    0x0440, 0x0441, 0x0442, 0x0443, 0x0444, 0x0445, 0x0446, 0x0447,  // р-ч
    0x0448, 0x0449, 0x044A, 0x044B, 0x044C, 0x044D, 0x044E, 0x044F,  // ш-я
};

// windows-1252 C1 range (0x80-0x9F); 0xA0-0xFF is identical to Latin-1.
constexpr uint16_t CP1252_C1[32] = {
    0x20AC, UNASSIGNED, 0x201A, 0x0192, 0x201E, 0x2026, 0x2020, 0x2021,      // 0x80-0x87
    0x02C6, 0x2030, 0x0160, 0x2039, 0x0152, UNASSIGNED, 0x017D, UNASSIGNED,  // 0x88-0x8F
    UNASSIGNED, 0x2018, 0x2019, 0x201C, 0x201D, 0x2022, 0x2013, 0x2014,      // 0x90-0x97
    0x02DC, 0x2122, 0x0161, 0x203A, 0x0153, UNASSIGNED, 0x017E, 0x0178,      // 0x98-0x9F
};

bool equalsIgnoreCase(const char* a, const char* b) {
  while (*a && *b) {
    char ca = *a;
    char cb = *b;
    if (ca >= 'A' && ca <= 'Z') ca += 'a' - 'A';
    if (cb >= 'A' && cb <= 'Z') cb += 'a' - 'A';
    if (ca != cb) return false;
    a++;
    b++;
  }
  return *a == *b;
}

void fillAscii(XML_Encoding* info) {
  for (int i = 0; i < 128; i++) {
    info->map[i] = i;
  }
}

int XMLCALL unknownEncodingHandler(void* /* data */, const XML_Char* name, XML_Encoding* info) {
  info->data = nullptr;
  info->convert = nullptr;
  info->release = nullptr;

  if (equalsIgnoreCase(name, "windows-1251") || equalsIgnoreCase(name, "cp1251")) {
    fillAscii(info);
    for (int i = 0; i < 128; i++) {
      info->map[128 + i] = (CP1251_HIGH[i] == UNASSIGNED) ? -1 : CP1251_HIGH[i];
    }
    return XML_STATUS_OK;
  }

  if (equalsIgnoreCase(name, "windows-1252") || equalsIgnoreCase(name, "cp1252")) {
    fillAscii(info);
    for (int i = 0; i < 32; i++) {
      info->map[128 + i] = (CP1252_C1[i] == UNASSIGNED) ? -1 : CP1252_C1[i];
    }
    for (int i = 0xA0; i <= 0xFF; i++) {
      info->map[i] = i;  // Latin-1 identity range
    }
    return XML_STATUS_OK;
  }

  return XML_STATUS_ERROR;
}
}  // namespace

void fb2RegisterExtraEncodings(XML_Parser parser) {
  XML_SetUnknownEncodingHandler(parser, unknownEncodingHandler, nullptr);
}
